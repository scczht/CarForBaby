# IAR project demo.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S105K4 STM8S105K4
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: ; STM8S_StdPeriph_Driver\inc
  ICCSTM8.IccLang: 0
  ILINK.IlinkOutputFile: demo.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group (top)
    STM8S_StdPeriph_Driver/src/: stm8s_uart2.c
  group StdPeriph_Driver
    STM8S_StdPeriph_Driver/src/: stm8s_clk.c stm8s_exti.c stm8s_gpio.c stm8s_i2c.c stm8s_spi.c stm8s_tim1.c stm8s_tim2.c stm8s_tim4.c
  group user
    ./: delay.c delay.h main.c nrf24l01.c nrf24l01.h stm8s_conf.h stm8s_it.c stm8s_it.h
    STM8S_StdPeriph_Driver/inc/: stm8s.h
  group user/inc
    STM8S_StdPeriph_Driver/inc/: stm8s_clk.h stm8s_exti.h stm8s_gpio.h stm8s_i2c.h stm8s_spi.h stm8s_tim1.h stm8s_tim2.h stm8s_tim4.h stm8s_uart1.h
